Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-04-04T15:27:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220111_1110(x64) - Exporter 19.2.50.16 - Alternate UI 19.2.50.16
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Apr 04 15:27:05 2022* Host: NCL-ManOps17* Database: C:\Users\bateyjo\AppData\Local\Temp\{A302A3C8-86C8-41F6-A70A-980CC9BCA893}\ifc* Database version: 5507* Database creation date: Mon Apr 04 15:27:05 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Apr 04 15:27:05 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Apr 04 15:27:05 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: Subway3.0MirrorA46471, NBS_VilleroyAndBochAG_BthrmMrrs_Subway3.0MirrorA46471:Subway3.0MirrorA46471:496666
In: Level 0
Type - ElementType: Subway3.0MirrorA46471; Classification: Pr_25_71_53_06 (Uniclass2015); Material: NBS_VilleroyAndBoch_BlackMatt, NBS_VilleroyAndBoch_Mirror
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_BathroomMirrors_Subway3.0_Mirror_A46471; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/ysuqt4xb; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/A46471; Uniclass2015Title: Bathroom mirrors; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Version: Products v1.22; Version: 3
Type - NBS_Data - Colour: 2700 K (warm white) to 6500 K (daylight white); ContainsRedListMaterials: n/a; ControlMethod: Sensor dimmer; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; Dimensions: 712 x 712 x 45 mm; EmbodiedCarbon: n/a; Form: Wall mounted; IngressProtection: 44; IntegralAccessories: None, ZigBee Home Automation Kit C004 00; LEDLighting: 1 x LED (17.28W); Manufacturer: Villeroy and Boch; MaterialsFrame: Aluminium; MaterialsGlazing: Toughened glass; PowerSupply: Mains-operated; Recyclability: n/a; RecycledContent: n/a; Weight: 7.5 kg
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: BATHMIRROR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: Villeroy and Boch; Material: n/a; ModelNumber: A46471; ModelReference: Subway3.0_Mirror_A46471; Name: BathroomMirrors_Subway3.0_Mirror_A46471_VilleroyAndBochAG; NominalHeight: 712 mm; NominalLength: 0 mm; NominalWidth: 712 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
